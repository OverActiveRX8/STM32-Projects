# Keil uVision project LVGLDemo.uvprojx, settings and files
target LVGLDemo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: LVGLDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\LCDlib\Inc;..\lvgl;..\lvgl\src\lv_core;..\lvgl\src\lv_draw;..\lvgl\src\lv_font;..\lvgl\src\lv_hal;..\lvgl\src\lv_misc;..\lvgl\src\lv_objx;..\lvgl\src\lv_themes;..\..\LVGLDemo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c lv_example.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LCDlib
    ../LCDlib/Src/: 24cxx.c ctiic.c delay.c ft5206.c gt9147.c lcd.c myiic.c ott2001a.c sys.c touch.c usart.c usmart.c usmart_config.c usmart_str.c
  group lv_core
    ../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lv_hal
    ../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lv_objx
    ../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lv_themes
    ../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
software components: CMSIS:CORE 5.3.0
